# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_M0_Base (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MSPM0G3507_M0_Base +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..;..\Application;..\Config;..\BSP\Display;..\BSP\Peripherals;..\Lib\OSAL;..\Lib\FreeRTOS\include;..\Lib\FreeRTOS\portable\MemMang;..\Lib\FreeRTOS\portable\GCC\ARM_CM0;..\Lib\FreeRTOS\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: main.c
    ../Config/: ti_msp_dl_config.c ti_msp_dl_config.h FreeRTOSConfig.h empty.syscfg startup_mspm0g350x_uvision.s
    ../Docs/: README.md
  group App
    ../Application/: app_main.c app_main.h
  group Lib/OSAL
    ../Lib/OSAL/: osal_api.h osal_config.h osal_critical.c osal_delay.c osal_mutex.c osal_queue.c osal_sem.c osal_task.c
  group Config
    ../Config/: project_config.h
  group Lib/FreeRTOS/src
    ../Lib/FreeRTOS/src/: list.c queue.c tasks.c timers.c
  group Lib/FreeRTOS/portable
    ../Lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../Lib/FreeRTOS/portable/GCC/ARM_CM0/: port.c
  group BSP/Display
    ../BSP/Display/: oled.c oled_port.c font.c oled.h oled_port.h font.h
  group BSP/Peripherals
    ../BSP/Peripherals/: bsp_ir.c bsp_debug.c bsp_ir.h
