# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__;LOG_LEVEL=LOG_LEVEL_INFO;TEST_MATHACL_ENABLE=1;TEST_MATHACL_INCLUDE_FULL_BENCHMARK=1;TEST_MATHACL_MATRIX_ENABLE=0;EKF_NIS_MONITOR=1;EKF_MANEUVER_DETECT=1
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\;..\Application;..\Application\test;..\Application\Task;..\Application\Algorithm;..\Filter;..\BSP;..\BSP\Peripherals;..\BSP\Devices;..\BSP\IMU;..\BSP\IMU\Ports\mspm0g3507;..\Lib\OSAL;..\Config;..\Lib\AxiomTrace;..\Lib\Math;..\Lib\FreeRTOS\include;..\Lib\FreeRTOS\portable\MemMang;..\Lib\FreeRTOS\portable\GCC\ARM_CM0;..\Lib\FreeRTOS\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: main.c
    ../Config/: ti_msp_dl_config.c ti_msp_dl_config.h FreeRTOSConfig.h empty.syscfg startup_mspm0g350x_uvision.s board.c board.h
    ../Docs/: README.md
  group App
    ../Application/: app_main.c app_main.h app_vofa.c app_vofa.h app_debug.c app_debug.h app_ble_service.c app_ble_service.h
    ../Application/Algorithm/: app_pid.c app_pid.h app_feedforward.c app_feedforward.h app_planner.c app_planner.h app_position_control.c app_position_control.h app_model_id.c app_model_id.h app_complementary_filter.c app_complementary_filter.h
    ../Application/Task/: task_control.c task_control.h task_menu.c task_menu.h task_imu.c task_imu.h
    ../Filter/: filter.h filter_config.h filter_config.c filter_core.c filter_complementary.c filter_lpf.c filter_ekf.c filter_lkf.c filter_mahony.c filter_madgwick.c filter_kf.c
    ../Application/test/: app_test_runner.c app_test_runner.h app_test_timer.c app_test_timer.h
  group BSP/Peripherals/HAL
    ../BSP/Peripherals/: hal_adc.c hal_adc.h hal_common.h hal_gpio.c hal_gpio.h hal_timer.c hal_timer.h hal_uart.c hal_uart.h
  group Lib/OSAL
    ../Lib/OSAL/: osal_api.h osal_config.h osal_critical.c osal_delay.c osal_mutex.c osal_queue.c osal_sem.c osal_task.c
  group Config
    ../Config/: project_config.h
  group Lib/FreeRTOS/src
    ../Lib/FreeRTOS/src/: list.c queue.c tasks.c timers.c
  group Lib/FreeRTOS/portable
    ../Lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../Lib/FreeRTOS/portable/GCC/ARM_CM0/: port.c
  group BSP
    ../BSP/Peripherals/: bsp_motor.c bsp_drv8870.c bsp_tb6612.c bsp_timer.c bsp_adc.c bsp_adc.h bsp_encoder.c bsp_encoder.h bsp_led.h bsp_led.c bsp_motor.h bsp_drv8870.h bsp_tb6612.h bsp_uart.c bsp_uart.h bsp_ble_uart.c bsp_ble_uart.h bsp_mathacl.h
    ../BSP/: bsp_common.h platform.c platform.h
    ../BSP/Devices/: jdy23.c jdy23.h
  group Lib/Math
    ../Lib/Math/: mathacl_matrix.h mathacl_matrix.c
  group BSP/IMU
    ../BSP/IMU/: lsm6dsr.c lsm6dsr.h bsp_lsm6dsr.c bsp_lsm6dsr.h
    ../BSP/IMU/Ports/mspm0g3507/: platform_mspm0.c spi_bridge.c spi_bridge.h
  group Lib/AxiomTrace
    ../Lib/AxiomTrace/: axiom_config.h axiom_port.h axiom_frontend.h axiomtrace.h
    ../Lib/AxiomTrace/Ports/mspm0/: axiom_port_mspm0.c
target empty_LP_MSPM0G3507_drv8870_factory_test (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: as above
  output: empty_LP_MSPM0G3507_drv8870_factory_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__;LOG_LEVEL=LOG_LEVEL_INFO;TEST_MATHACL_ENABLE=1;TEST_MATHACL_INCLUDE_FULL_BENCHMARK=1;TEST_MATHACL_MATRIX_ENABLE=0;EKF_NIS_MONITOR=1;EKF_MANEUVER_DETECT=1;PRJ_DRV8870_FACTORY_TEST_ENABLE=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: as above
